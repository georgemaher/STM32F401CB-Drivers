# Keil uVision project RCC.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F401VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RCC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c RCC.c
  group Inc
    ./: STD_Types.h RCC_cnfg.h RCC_DEFS.h RCC.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 2.6.3
