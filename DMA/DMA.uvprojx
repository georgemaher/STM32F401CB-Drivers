# Keil uVision project DMA.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F401CBUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DMA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\GPIO;..\RCC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group exe
    ../RCC/: RCC.c
    ./: DMA.c main.c
  group inc
    ./: DMA_CNFG.h DMA.h DMA_PRIV.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDIN:ITM 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 2.6.3
